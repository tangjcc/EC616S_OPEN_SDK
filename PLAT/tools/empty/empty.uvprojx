# Keil uVision project empty.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: EC616 Eigencomm
  pack: Eigencomm.EC616.1.0.4
  cpu: IRAM(0x04000000,0x40000) IROM(0x08000000,0x400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app-demo-flash
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x4000000 size 0x40000
